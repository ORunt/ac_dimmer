# Keil uVision project ac_dimmer.uvprojx, settings and files
target ac_dimmer (6160000::V6.16::ARMCLANG)
  device: STM32F030C6Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: ac_dimmer +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: USE_STDPERIPH_DRIVER
  c include: .\src;.\inc
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group src
    ./src/: main.c stm32f0xx_it.c
  group periphials
    ./src/: stm32f0xx_exti.c stm32f0xx_gpio.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_misc.c stm32f0xx_syscfg.c
  group inc
    ./inc/: stm32f0xx.h stm32f0xx_exti.h stm32f0xx_gpio.h stm32f0xx_rcc.h stm32f0xx_rtc.h stm32f0xx_tim.h stm32f0xx_usart.h system_stm32f0xx.h stm32f0xx_conf.h stm32f0xx_misc.h stm32f0xx_syscfg.h stm32f0xx_it.h main.h
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
